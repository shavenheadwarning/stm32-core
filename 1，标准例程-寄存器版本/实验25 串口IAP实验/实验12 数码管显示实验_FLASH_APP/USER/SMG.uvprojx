# Keil uVision project SMG.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SMG +hex
  AfterMake: D:\tool\MDK\MDK5.23\ARM\ARMCC\bin\fromelf.exe  --bin -o  ..\OBJ\SMG.bin ..\OBJ\SMG.axf
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\SMG;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8002800 size 0x1d800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group1
    ./: startup_stm32f10x_md.s
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SMG/: smg.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: README.TXT
